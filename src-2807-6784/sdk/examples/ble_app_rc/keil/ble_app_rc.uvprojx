# Keil uVision project ble_app_rc.uvprojx, settings and files
target ble_app_rc (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_rc +hex
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L..\@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_AUTOCONF_VERSION CONFIG_LOG_OUTPUT
  c misc: -Wno-expansion-to-defined
  c include: ..\..\..\..\coroutine;..\..\..\..\hardware\cmsis;..\..\..\..\hardware\cfg;..\..\..\..\hardware\sys;..\..\..\..\hardware\peripheral;..\..\..\..\hardware\mbr;..\..\..\..\host\gatt;..\..\..\..\host\port;..\..\..\..\host\smp;..\..\..\..\host\gap;..\..\..\..\host\att;..\..\..\..\host\common\app_sec;..\..\..\..\host\common\tspp;..\..\..\..\host\common;..\..\..\..\host\common\hid;..\..\..\..\host\include;..\..\..\..\host\l2cap;..\..\..\..\include;..\..\..\..\include\stack;..\..\..\..\third_party\sbc\bluedroid\srce;..\..\..\..\third_party\sbc\bluedroid\include;..\..\..\..\sdk\components\softdevice\common\softdevice_handler;..\..\..\..\sdk\components\softdevice\s110\headers;..\..\..\..\sdk\examples\common\app_sec;..\..\..\..\sdk\examples\common\app_nvds;..\..\..\..\hardware\radio\asic;..\..\..\..\lib\keil;..\..\..\components\ble\ble_db_discovery;..\..\..\components\ble\common;..\..\..\components\libraries\util;..\..\..\components\libraries\trace;..\..\..\components\device;..\config;..\board;..\app\app_uart;..\app\app_gap;..\profiles;..\profiles\ble_gap;..\profiles\ble_gatt;..\profiles\ble_dev_info;..\profiles\ble_batt;..\app\app_keyboard;..\app\app_mode;..\profiles\ble_hid;..\app\app_batt;..\app\app_led;..\app\app_ir;..\app\app_ir\ir_nec;..\app\app_ir\ir_driver;..\profiles\ble_atv;..\app\app_atv;..\modules\ring_buff;..\app\app_mic;..\app\app_mic\driver;..\modules\flash_protect;..\modules\encrypt;..\app\app_xihao_audio;..\..\common\app_privacy;..\..\..\..\include;..\profiles\ble_config;..\modules\sensor_3_axial_module;..\..\..\..\hardware\peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\lib\keil\scatter_xh98xx_flash_armclang.sct
  link misc: --via=..\..\..\..\lib\keil\armlink6.via
  group startup
    ../../../../lib/keil/: startup_xh98xx_flash.s
  group board
    ../board/: board_config.h board_demo.h
  group app
    ../: main.c
    ../app/app_gap/: app_gap.c
    ../app/app_uart/: app_uart.c
    ../app/app_keyboard/: key_scan.c app_keyboard.c
    ../app/app_mode/: app_mode.c
    ../app/app_led/: app_led.c
    ../app/app_batt/: app_batt.c
    ../app/app_ir/: app_ir.c
    ../app/app_ir/ir_nec/: driver_nec_code.c
    ../app/app_mic/: app_audio.c
    ../app/app_atv/: app_atv.c
  group profile
    ../profiles/ble_gap/: gap_service.c
    ../profiles/ble_gatt/: gatt_service.c
    ../profiles/ble_dev_info/: ble_dev_service.c
    ../profiles/ble_batt/: batt_service.c
    ../profiles/ble_hid/: hid_service.c
    ../profiles/ble_atv/: atv_service.c
    ../profiles/ble_config/: ble_config.lib
  group peripheral
    ../../../../hardware/peripheral/: adc.c audio.c dma_nds.c cpm.c timer.c retarget.c i2s.c i2c.c
    ../app/app_ir/ir_driver/: irrx.c irtx.c
  group tools
    ../modules/ring_buff/: ringbuffer.c
    ../modules/flash_protect/: xh98xx_flash_protect.c
  group modules
    ../modules/charge_module/: lp4081b_driver.c mt5705_driver.c
    ../modules/led_module/: backlight_handle.c bct3236_driver.c
    ../modules/sensor_3_axial_module/: da228ec_driver.c sensor_data_process.c
    ../modules/sensor_optical_module/: ltr_x119a_driver.c
