# Keil uVision project 089-B2017B.uvprojx, settings and files
target PY32F030x4_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32F030x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x4
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ./: startup_py32f030xx.s
    ../Src/: system_py32f0xx.c
    ../common/: time_utils.c utility.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
    ../app/: app.c
    ../app/data_stream/: 2_4g_io.c flash_io.c
    ../app/control/: control_protocol.c
    ../fct/: fct.c fct_uart.c fct_protocol.c
    ../app/control/089-B2017B/: control_state.c key_handle.c led.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_gpio.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_pwr.c py32f0xx_hal_led.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_adc.c py32f0xx_hal_flash.c py32f0xx_hal_uart.c py32f0xx_hal_iwdg.c py32f0xx_hal_lptim.c
  group Hal_Adapater
    ../hal_adapter/keyboard/: key_driver.c key_evt_handle.c
    ../hal_adapter/led/: led_driver.c led_evt.c led_bar.c
    ../hal_adapter/power/: pm.c
    ../hal_adapter/radio/: pan216.c pan216_ext.c pan216_port.c pan216_reg.c
  group Jink_RTT
    ../Jlink_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target PY32F030x6_Project (6190000::V6.19::ARMCLANG)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x6_Templates +hex
  BeforeMake: E:\lkl\work\py32\panasonic-rcu\tool\version_tools.bat
  AfterMake: E:\lkl\work\py32\panasonic-rcu\tool\rename_outpu.bat
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=4 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x6
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\hal_adapter\keyboard;..\hal_adapter\led;..\hal_adapter\power;..\hal_adapter\rf_2_4g;..\common;..\app;..\app\control;..\app\data_stream;..\app\view;..\Jlink_RTT\RTT;..\Jlink_RTT\Config;..\hal_adapter\radio;..\fct
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32F030x7_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x7 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1800
target PY32F030x8_Project (6190000::V6.19::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 089-B2017B +hex
  BeforeMake: ..\tool\version_tools.bat @P
  AfterMake: ..\tool\rename_output.bat @P
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\common;..\app\control;..\app\data_stream;..\Jlink_RTT\RTT;..\Jlink_RTT\Config;..\hal_adapter\keyboard;..\hal_adapter\led;..\hal_adapter\power;..\hal_adapter\rf_2_4g;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\app;..\hal_adapter\radio;..\fct;..\app\control\089-B2017B;..\..\panasonic-rcu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.6.0
