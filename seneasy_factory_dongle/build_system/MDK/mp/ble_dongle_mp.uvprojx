# Keil uVision project ble_dongle_mp.uvprojx, settings and files
target ble_dongle_mp (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ble_dongle_mp +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MAIN_PROCESSOR MXD2670F03UB_DONGLE_EVB
  c include: ..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\sources\device\mxd2670\Include;..\..\..\sources\drivers\mxd\register;..\..\..\sources\drivers\mxd\hw\inc;..\..\..\sources\drivers\mxd\hal\inc;..\..\..\sources\patch\patch_hw\inc;..\..\..\sources\patch\patch_hal\inc;..\..\..\sources\boards;..\..\..\sources\components\debug;..\..\..\sources\components\debug\err_debug;..\..\..\sources\components\lpwr_ctrl;..\..\..\sources\components\rom_callback;..\..\..\sources\components\utility;..\..\..\sources\mem_cfg;..\..\config;..\..\..\sources\components\msg_queue;..\..\..\sources\components\ipc_general;..\..\..\sources\projects_source;..\..\..\sources\projects_source\components_private;..\..\..\sources\projects_source\module;..\..\..\sources\projects_source\ble_client
  asm define: __MAIN_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\ble_dongle_mp.sct
  link misc: --entry=Reset_Handler --keep=g_boot2LibCode --keep=g_u8CpAppCode
  group Startup Code
    ../../../sources/device/mxd2670/Source/ARM/: startup_ARMCM33.s
    ../../../sources/device/mxd2670/Source/: system_ARMCM33.c
  group lib
    ../../../libraries/rom/: mxd2670_rom_lib_mp_r2.lib
    ../../../libraries/patch/: mxd2670_patch_lib_mp_r2.lib
    ../../../libraries/boot2/: mxd2670_boot2_lib_r2.c
    ../cp/: app_code_cp.c
  group components
    ../../../sources/components/debug/: debug.c
    ../../../sources/components/debug/err_debug/: err_debug.c
    ../../../sources/components/lpwr_ctrl/: lpwr_ctrl.c
    ../../../sources/components/msg_queue/: msg_queue.c
    ../../../sources/components/ipc_general/: ipc_general_queue.c
  group main
    ../../../sources/projects_source/main/mp/: main.c
  group components_private
    ../../../sources/projects_source/components_private/: adpcm_lib_mp.lib
  group module
    ../../../sources/projects_source/module/: ipc.c usb_device.c usb_device_descriptor.c usb_device_dfu.c usb_device_dfu_descriptor.c usb_device_standard_request.c
  group application
    ../../../sources/projects_source/: app_dongle_mp.c
software components: CMSIS:CORE 5.4.0
