# Keil uVision project ble_dongle_cp.uvprojx, settings and files
target ble_dongle_cp (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_dongle_cp +hex
  AfterMake: .\ble_dongle_cp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  AfterMake: ..\..\..\tools\mlog\gen_mlog.bat  ble_dongle_cp  ..\..\..\
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CO_PROCESSOR MXD2670F03UB_DONGLE_EVB
  c include: ..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\Include;..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Include;..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Source;..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Config;..\..\..\sources\device\mxd2670\Include;..\..\..\sources\ble5.1\rf_init;..\..\..\sources\ble5.1\ble_init;..\..\..\sources\ble5.1\ble_stack\callback;..\..\..\sources\ble5.1\ble_stack\interface;..\..\..\sources\ble5.1\ble_stack\llp;..\..\..\sources\ble5.1\ble_stack\llc;..\..\..\sources\ble5.1\ble_stack\llc\llc_connection_role;..\..\..\sources\ble5.1\ble_stack\llc\llc_ctrl_procedure;..\..\..\sources\ble5.1\ble_stack\llc\llc_dtm;..\..\..\sources\ble5.1\ble_stack\llc\llc_legacy_role;..\..\..\sources\ble5.1\ble_stack\llc\llc_priority;..\..\..\sources\ble5.1\ble_stack\sec;..\..\..\sources\ble5.1\ble_stack\stack\host_stack;..\..\..\sources\ble5.1\ble_stack\stack\uecc;..\..\..\sources\ble5.1\ble_services\ble_dis;..\..\..\sources\ble5.1\ble_services\ble_gap;..\..\..\sources\ble5.1\ble_services\ble_gatt;..\..\..\sources\ble5.1\ble_services\ble_mus;..\..\..\sources\ble5.1\ble_services\ble_ota;..\..\..\sources\drivers\mxd\register;..\..\..\sources\drivers\mxd\hw\inc;..\..\..\sources\drivers\mxd\hal\inc;..\..\..\sources\patch\patch_ble;..\..\..\sources\patch\patch_ble\llp;..\..\..\sources\patch\patch_ble\llc;..\..\..\sources\patch\patch_ble\llc\llc_connection_role;..\..\..\sources\patch\patch_ble\stack;..\..\..\sources\patch\patch_ble\interface;..\..\..\sources\patch\patch_hw\inc;..\..\..\sources\patch\patch_hal\inc;..\..\..\sources\boards;..\..\..\sources\components\debug;..\..\..\sources\components\mlog;..\..\..\sources\components\debug\err_debug;..\..\..\sources\components\sw_timer;..\..\..\sources\components\crc;..\..\..\sources\components\lpwr_ctrl;..\..\..\sources\components\rand;..\..\..\sources\components\rom_callback;..\..\..\sources\components\utility;..\..\..\sources\mem_cfg;..\..\config;.\RTE\_ble_dongle_cp;..\..\..\sources\components\msg_queue;..\..\..\sources\components\ipc_general;..\..\..\sources\projects_source;..\..\..\sources\projects_source\components_private;..\..\..\sources\projects_source\ble_client;..\..\..\sources\projects_source\module;..\..\..\sources\components\nr_micro_shell\inc;..\..\..\sources\projects_source\module\shell
  asm define: __CO_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_dongle_cp.sct
  link misc: --entry=Reset_Handler
  group Startup Code
    ../../../sources/device/mxd2670/Source/ARM/: startup_ARMCM0plus.s
    ../../../sources/device/mxd2670/Source/: system_ARMCM0plus.c
  group config
    ../../config/: app_cfg.h ble_config.h
  group lib
    ../../../libraries/rom/: mxd2670_rom_lib_cp_r2.lib
    ../../../libraries/patch/: mxd2670_patch_lib_cp_r2.lib
  group rtos
    ../../../sources/projects_source/rtos/: idle_task.c
  group components
    ../../../sources/components/debug/: debug.c
    ../../../sources/components/mlog/: mlog_protocol.c mlog_transport_uart.c
    ../../../sources/components/debug/err_debug/: err_debug.c
    ../../../sources/components/sw_timer/: sw_timer.c
    ../../../sources/components/lpwr_ctrl/: lpwr_ctrl.c
    ../../../sources/components/msg_queue/: msg_queue.c
    ../../../sources/components/ipc_general/: ipc_general_queue.c
    ../../../sources/components/nr_micro_shell/src/: ansi.c ansi_port.c nr_micro_shell.c
  group ble_stack
    ../../../sources/ble5.1/rf_init/: rf_init.c
    ../../../sources/ble5.1/ble_init/: ble_init.c ble_controller_init.c ble_host_init.c ble_interface_init.c
  group profile
    ../../../sources/ble5.1/ble_services/ble_mus/: ble_mus.c
  group main
    ../../../sources/projects_source/main/cp/: main.c app_main.c
  group ble_client
    ../../../sources/projects_source/ble_client/: atvv_client.c battery_client.c hid_client.c ota_client.c
  group components_private
    ../../../sources/projects_source/components_private/: adpcm_lib.lib
  group module
    ../../../sources/projects_source/module/: ble_central.c ble_event.c ipc.c led.c
    ../../../sources/projects_source/module/shell/: shell_port.c shell_cmd.c
  group application
    ../../../sources/projects_source/: app_dongle.c
software components: CMSIS:CORE 5.4.0
