# Keil uVision project flash_algorithm.uvprojx, settings and files
target flash_algorithm (6140000::V6.14::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: Algorithm +hex
  AfterMake: cmd.exe /c copy "Objects\Algorithm.axf" "$KARM\Flash\MXD267x_FLASH_V1.4.FLM"
  AfterMake: cmd.exe /c copy "Objects\Algorithm.axf" "..\..\MXD267x_FLASH_V1.4.FLM"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MAIN_PROCESSOR MXD2670F03UD_EVB
  c include: ..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\sources\drivers\mxd\register;..\..\..\..\sources\drivers\mxd\hw\inc;..\..\..\..\sources\drivers\mxd\hal\inc;..\..\..\..\sources\drivers\ext_flash;..\..\..\..\sources\mem_cfg;..\..\..\..\sources\boards;..\..\..\..\sources\components\debug;..\..\..\..\sources\components\utility;..\src\main;..\src\config
  asm define: __MAIN_PROCESSOR
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group drivers
    ../../../../sources/drivers/mxd/hw/src/: hw_pmu.c hw_crg.c hw_efuse.c hw_gpio.c hw_flash.c hw_uart.c hw_wdt.c hw_sys_ctrl.c
  group components
    ../../../../sources/components/debug/: debug.c
    ../src/utility/: utility.c utility_asm.s
  group main
    ../src/main/: flash_prog.c FlashDev.c
software components: CMSIS:CORE 5.4.0
