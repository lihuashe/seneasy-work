# Keil uVision project rcu.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_define.h --bss_threshold=0
  c include: ..\rcu;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\src\ble\profile\server;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\inc\peripheral;..\..\..\inc\os;..\..\..\src\app\rcu;..\..\..\..\bluetooth\crypto;..\..\..\src\app\rcu\voice_module;..\..\..\src\app\rcu\uart_test;..\..\..\src\app\rcu\led_module;..\..\..\src\app\rcu\key_module;..\..\..\src\app\rcu\ir_module;..\..\..\src\app\rcu\bat_module;..\..\..\src\app\rcu\test_module;..\..\..\src\ble\privacy;..\..\..\src\app\rcu\ota_module;..\..\..\src\app\rcu\rtc_module
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
    ./: mem_config.h board.h otp_config.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_utils.lib msbc_lib.lib sbc_lib.lib ima_adpcm_lib.lib bee2_adc_lib.lib auto_k_rf_bonding_lib_DUT.lib auto_k_rf.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_keyscan.c rtl876x_rcc.c rtl876x_uart.c rtl876x_i2s.c rtl876x_ir.c rtl876x_codec.c rtl876x_adc.c rtl876x_tim.c rtl876x_lpc.c
  group profile
    ../../../src/ble/profile/server/: dis.c bas.c hids_rmc.c vendor_service.c atvv_service.c rcu_dfu_service.c rcu_ota_service.c voice_service.c
  group app
    ../../../src/app/rcu/: main.c rcu_application.c rcu_gap.c swtimer.c app_task.c reset_watch_dog_timer.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/ble/privacy/: privacy_mgnt.c
    ../../../src/flash/: silent_dfu_flash.c
  group key
    ../../../src/app/rcu/key_module/: keyscan_driver.c key_handle.c
  group voice
    ../../../src/app/rcu/voice_module/: voice_driver.c voice.c
  group ir
    ../../../src/app/rcu/ir_module/: ir_send_app.c ir_nec_encode.c ir_repeat_code.c ir_learn.c ir_learn_app.c data_trans.c
  group led
    ../../../src/app/rcu/led_module/: led_driver.c
  group battery
    ../../../src/app/rcu/bat_module/: battery_driver.c
  group test
    ../../../src/app/rcu/test_module/: mp_test.c single_tone.c data_uart_test.c uart_transport.c
  group rtc
    ../../../src/app/rcu/rtc_module/: rtc_driver.c
