# Keil uVision project tx.uvprojx, settings and files
target tx (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: tx +hex
  AfterMake: cmd.exe /c $J\..\bin\fromelf.exe --bin -o "bin/@L.bin" "#L" && $J\..\bin\fromelf.exe -acd --interleave=source -o "bin/@L.disasm" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: CONFIG_FLASH_LINE_MODE=2
  c include: ..\..\..\..\pan108\cmsis\include;..\..\..\..\pan108\peripheral\inc;..\..\..\..\pan108\device\Include;..\src;..\..\..\..\middleware;..\..\..\..\radio;..\..\..\..\pan108
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group common
    ../../../../pan108/device/Source/: system_PANSeries.c
    ../../../../pan108/device/Source/arm/: startup_PANSeries.s
    ../../../../pan108/: bsp.c
  group driver
    ../../../../pan108/device/Source/: pan_clk.c pan_sys.c pan_retarget.c
    ../../../../pan108/peripheral/src/: pan_fmc.c pan_gpio.c pan_spi.c pan_uart.c pan_dmac.c pan_timer.c
  group middleware
    ../../../../middleware/: fifo.c fifo.h log.c log.h
  group radio
    ../../../../radio/: pan216.c pan216_port.c pan216_reg.c pan216_ext.c
  group source
    ../src/: main.c key_process.c key_process.h oled.c oled.h oledfont.h rf_frame.h
