# Keil uVision project rcu.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\..\tool\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_define.h --preinclude mem_config.h --bss_threshold=0
  c include: ..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\rcu;..\..\..\..\src\app\rcu;..\..\..\..\src\app\rcu\bat_module;..\..\..\..\src\app\rcu\ir_module;..\..\..\..\src\app\rcu\key_module;..\..\..\..\src\app\rcu\led_module;..\..\..\..\src\app\rcu\test_module;..\..\..\..\src\app\rcu\rtc_module;..\..\..\..\src\ble;..\..\..\..\src\ble\profile\server;..\..\..\..\src\ble\privacy;..\..\..\..\inc\app;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\platform;..\..\..\..\inc\peripheral;..\..\..\..\inc\os;..\..\..\..\inc\rcu;..\..\..\..\src\dfu;..\..\..\..\inc\platform;..\..\..\..\src\app\rcu\uart_module;..\..\..\..\src\app\rcu\buzzer_module;..\..\..\..\src\app\rcu\voltage_module
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
    ../: otp_config.h mem_config.h board.h
  group lib
    ../../../../bin/mdk/: ROM.lib sbc_lib.lib msbc_lib.lib ima_adpcm_lib.lib auto_k_rf.lib auto_k_rf_bonding_lib_DUT.lib gap_utils.lib adc.lib bee3_sdk.lib
  group cmsis
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_gpio.c rtl876x_ir.c rtl876x_keyscan.c rtl876x_rtc.c rtl876x_codec.c rtl876x_i2s.c rtl876x_pinmux.c rtl876x_nvic.c rtl876x_rcc.c rtl876x_tim.c rtl876x_gdma.c rtl876x_uart.c rtl876x_adc.c rtl876x_lpc.c rtl876x_aon_wdg.c rtl876x_i2c.c rtl876x_enh_tim.c
  group profile
    ../../../../src/ble/profile/server/: dis.c bas.c hids_rmc.c vendor_service.c voice_service.c atvv_service.c ota_service.c dfu_service.c
  group app
    ../../../../src/app/rcu/: main.c rcu_application.c rcu_gap.c swtimer.c app_task.c reset_watch_dog_timer.c loop_queue.c app_function.c
    ../../../../src/ble/privacy/: privacy_mgnt.c
    ../../../../src/mcu/rtl876x/: overlay_mgr.c
  group dfu
    ../../../../src/dfu/: dfu_main.c dfu_task.c dfu_application.c
    ../../../../src/platform/: dfu_flash.c
  group key
    ../../../../src/app/rcu/key_module/: keyscan_driver.c key_handle.c keyscan_basic_driver.c key_config.c
  group led
    ../../../../src/app/rcu/led_module/: aw21036_driver.c bct3236_driver.c i2c_init.c led_config.c
  group battery
    ../../../../src/app/rcu/bat_module/: battery_driver.c lp4081h_driver.c usb_chg.c
  group test
    ../../../../src/app/rcu/test_module/: data_uart_test.c mp_test.c single_tone.c uart_transport.c
  group rtc
    ../../../../src/app/rcu/rtc_module/: rtc_driver.c
  group uart
    ../../../../src/app/rcu/uart_module/: production_test.c uart_driver.c
  group buzzer
    ../../../../src/app/rcu/buzzer_module/: buzzer.c
  group voltage
    ../../../../src/app/rcu/voltage_module/: voltage_driver.c
